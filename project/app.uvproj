# Keil uVision project app.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: app +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\src;..\STM32F10x_Lib\inc;..\Startup_config;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III\Ports;..\UCOSIII\uCOS-III\Source;..\UCOSIII\UCOS_BSP;..\UCOSIII\UCOS_CONFIG
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../src/: main.c
  group src
    ../src/: delay.c led.c sys.c usart.c
  group starup_config
    ../Startup_config/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group stm32f10x_lib
    ../STM32F10x_Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group ucosiii_bsp
    ../UCOSIII/UCOS_BSP/: bsp.c
  group ucosiii_cpu
    ../UCOSIII/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group ucosiii_lib
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group ucosiii_core
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucosiii_port
    ../UCOSIII/uCOS-III/Ports/: os_cpu_a.s os_cpu_c.c
  group ucosiii_config
    ../UCOSIII/uCOS_CONFIG/: os_app_hooks.c
